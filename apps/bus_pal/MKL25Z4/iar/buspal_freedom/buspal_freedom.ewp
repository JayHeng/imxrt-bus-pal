# IAR project buspal_freedom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG; CPU_MKL25Z128VLK4; CPU_IS_ARM_CORTEX_M0P=1; DISABLE_WDOG=1; BUSPAL=1; CLOCK_SETUP=1; IAR; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../src; ../../src; ../../../../../targets/MKL25Z4/src; ../../../../../targets/MKL25Z4/src/startup; ../../../../../src/platform/devices/MKL25Z4; ../../../../../src/drivers/common; ../../../../../src/include; ../../../../../src/platform; ../../../../../src/platform/devices; ../../../../../src/platform/CMSIS/Include; ../../../../../src; ../../../../../src/drivers; ../../../../../src/startup; ../../../../../src/drivers/uart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../../../../../src/include
  OBJCOPY.OOCOutputFile: generic.srec
  ILINK.IlinkOutputFile: buspal_freedom.elf
  ILINK.IlinkIcfFile: ../../../linker/iar/bus_pal.icf
  ILINK.IlinkExtraOptions: --redirect __aeabi_idiv=__iar_small___aeabi_idiv; --redirect __aeabi_uidiv=__iar_small___aeabi_uidiv; --redirect __aeabi_idivmod=__iar_small___aeabi_idivmod; --redirect __aeabi_uidivmod=__iar_small___aeabi_uidivmod
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKL25Z128VLK4; CPU_IS_ARM_CORTEX_M0P=1; DISABLE_WDOG=1; BUSPAL=1; CLOCK_SETUP=1; IAR; FREEDOM
  AARM.ADefines: NDEBUG
  group link
    ../../../linker/iar/: bus_pal.icf
  group MKL25Z4/bus_pal_FRDM-KL25Z/src
    ../../src/: bus_pal_hardware.c bus_pal_hardware.h
    ../../../src/: buspal_config.h command_handle.c command_handle.h main.c
  group MKL25Z4/drivers/i2c
    ../../../../../src/drivers/i2c/: fsl_i2c.c fsl_i2c.h
  group MKL25Z4/drivers/microseconds
    ../../../../../src/drivers/microseconds/: microseconds.h
    ../../../../../src/drivers/microseconds/src/: microseconds_sysclk.c
  group MKL25Z4/drivers/spi
    ../../../../../src/drivers/spi/: fsl_spi.c fsl_spi.h
  group MKL25Z4/drivers/uart
    ../../../../../src/drivers/lpsci/: fsl_lpsci.c fsl_lpsci.h
  group MKL25Z4/utilities
    ../../../../../src/utilities/src/: bootloader_tree_stub.c fsl_assert.c fsl_rtos_abstraction.c
  group src/startup
    ../../../../../src/startup/: boot.s crt0.s startup.c
    ../../../../../targets/MKL25Z4/src/startup/iar/: startup_MKL25Z4.s
    ../../../../../targets/MKL25Z4/src/startup/: system_MKL25Z4.c
